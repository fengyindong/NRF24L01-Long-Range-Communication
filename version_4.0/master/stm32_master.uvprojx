# Keil uVision project stm32_master.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\library;.\user;.\hardware_drive
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ./cmsis/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group hardware_drive
    ./hardware_drive/: app_protocol.c app_protocol.h board.c board.h clm970.c clm970.h gateway.c gateway.h master_config.h mqtt_command.c mqtt_command.h nrf24.c nrf24.h
  group library
    ./library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group user
    ./user/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
